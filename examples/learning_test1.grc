options:
  parameters:
    generate_options: qt_gui
    id: Learning_Test_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: gui_in_i
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Input I
    orient: Qt.Horizontal
    start: '-1.0'
    step: '0.01'
    stop: '1.0'
    value: '0.1'
  states: {}
- name: gui_in_q
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Input Q
    orient: Qt.Horizontal
    start: '-1.0'
    step: '0.01'
    stop: '1.0'
    value: '0.9'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: mszlearning_gen1_0
  id: mszlearning_gen1
  parameters:
    in_i: gui_in_i
    in_q: gui_in_q
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,4,2
    label1: Signal I
    label2: Signal Q
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [mszlearning_gen1_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
